org 1234H 
START: LJMP START
ACALL TMP1
ADD A,R1
ADD A,10H
ADD A, @R1
ADD A,#12H
TMP1:ADDC A, R1
ADDC A,14H
ADDC A,@R1
ADDC A,#47H
AJMP TMP1
ANL A,R6
ANL A, 56H
ANL A,@R1
ANL A,#87H
ANL 09H,A
ANL 78H,#43H
ANL C,81H
ANL C,/81H
TMP2:CJNE A,34H,TMP2
CJNE A,#43H,TMP1
CJNE R6,#54H,TMP1
CJNE @R0,#54H,TMP1
CLR A
CLR C
CLR 82H
CPL A
CPL C
CPL 82H
DA A
DEC A
DEC R4
DEC 23H
DEC @R1
DIV AB
DJNZ R2,TMP1
DJNZ 43H,TMP2
INC A
INC R3
INC 56H
INC @R1
INC DPTR
JB 34H,TMP1
JBC 32H,TMP2
JC TMP1
JMP @A+DPTR
JNB 34H,TMP1
JNC TMP2
JNZ TMP1
JZ TMP2
LCALL TMP1
LJMP TMP2
MOV A,R5
MOV A,34H
MOV A,@R0
MOV A,#32H
MOV R5,A
MOV R2,34H
MOV R4,#32H
MOV 43H,A
MOV 32H,R2
MOV 32H,54H
MOV 32H,@R1
MOV 67H,#32H
MOV @R1,A
MOV @R0,87H
MOV @R1,#23H
MOV C,82H
MOV 83H,C
MOV DPTR,#1234H
MOVC A,@A+DPTR
MOVC A,@A+PC
MOVX A,@R0
MOVX A,@DPTR
MOVX @R1,A
MOVX @DPTR,A
MUL AB
NOP
ORL A,R6
ORL A,87H
ORL A,@R0
ORL A,#32H
ORL 98H,A
ORL 43H,#23H
ORL C,98H
ORL C,/23H
POP 34H
PUSH 34H
RET
RETI
TMP3:RL A
RLC A
RR A
RRC A
SETB 93H
SETB C
SJMP TMP3
SUBB A,R5
SUBB A,43H
SUBB A,@R0
SUBB A,#21H
SWAP A
XCH A,R4
XCH A,12H
XCH A,@R0
XCHD A,@R1
XRL A,R2




end
