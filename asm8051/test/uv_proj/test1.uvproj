# Keil uVision project test1.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G1K08 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: test1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: test_any.a51
