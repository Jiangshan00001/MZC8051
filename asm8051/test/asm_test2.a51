ORG 100H
ADDR_TEST1:


JC ADDR_TEST1;
JNC ADDR_TEST1;
JB 63H,ADDR_TEST1;
JB 54H,ADDR_TEST1;
JB 23H,ADDR_TEST1;
JNB 63H,ADDR_TEST1;
JNB 54H,ADDR_TEST1;
JNB 23H,ADDR_TEST1;
JBC 63H,ADDR_TEST1;
JBC 54H,ADDR_TEST1;
JBC 23H,ADDR_TEST1;

ACALL ADDR_TEST1;
LCALL ADDR_TEST1;
RET;
RETI;
AJMP ADDR_TEST1;
LJMP ADDR_TEST1;
SJMP ADDR_TEST1;
JMP @A+DPTR;
JZ ADDR_TEST1;
JNZ ADDR_TEST1;
CJNE A,63H, ADDR_TEST1;
CJNE A,54H, ADDR_TEST1;
CJNE A,23H, ADDR_TEST1;
CJNE A,#1234H, ADDR_TEST1;
CJNE A,#12H, ADDR_TEST1;
CJNE A,#78H, ADDR_TEST1;
CJNE R0,#1234H, ADDR_TEST1;
CJNE R0,#12H, ADDR_TEST1;
CJNE R0,#78H, ADDR_TEST1;
CJNE R7,#1234H, ADDR_TEST1;
CJNE R7,#12H, ADDR_TEST1;
CJNE R7,#78H, ADDR_TEST1;
CJNE R3,#1234H, ADDR_TEST1;
CJNE R3,#12H, ADDR_TEST1;
CJNE R3,#78H, ADDR_TEST1;
CJNE @R0,#1234H, ADDR_TEST1;
CJNE @R0,#12H, ADDR_TEST1;
CJNE @R0,#78H, ADDR_TEST1;
CJNE @R1,#1234H, ADDR_TEST1;
CJNE @R1,#12H, ADDR_TEST1;
CJNE @R1,#78H, ADDR_TEST1;
DJNZ R0,ADDR_TEST1;
DJNZ R7,ADDR_TEST1;
DJNZ R3,ADDR_TEST1;
DJNZ 63H,ADDR_TEST1;
DJNZ 54H,ADDR_TEST1;
DJNZ 23H,ADDR_TEST1;
ADD A,R0;
ADD A,R7;
ADD A,R3;
ADD A,63H;
ADD A,54H;
ADD A,23H;
ADD A,@R0;
ADD A,@R1;
ADD A,#1234H;
ADD A,#12H;
ADD A,#78H;
ADDC A,R0;
ADDC A,R7;
ADDC A,R3;
ADDC A,63H;
ADDC A,54H;
ADDC A,23H;
ADDC A,@R0;
ADDC A,@R1;
ADDC A,#1234H;
ADDC A,#12H;
ADDC A,#78H;
SUBB A,R0;
SUBB A,R7;
SUBB A,R3;
SUBB A,63H;
SUBB A,54H;
SUBB A,23H;
SUBB A,@R0;
SUBB A,@R1;
SUBB A,#1234H;
SUBB A,#12H;
SUBB A,#78H;
INC A;
INC R0;
INC R7;
INC R3;
INC 63H;
INC 54H;
INC 23H;
INC @R0;
INC @R1;
DEC A;
DEC R0;
DEC R7;
DEC R3;
DEC 63H;
DEC 54H;
DEC 23H;
DEC @R0;
DEC @R1;
INC DPTR;
MUL AB;
DIV AB;
DA A;
CLR C;
CLR 63H;
CLR 54H;
CLR 23H;
SETB C;
SETB 63H;
SETB 54H;
SETB 23H;
CPL C;
CPL 63H;
CPL 54H;
CPL 23H;
ANL C,63H;
ANL C,54H;
ANL C,23H;
ANL C,/23H;
ORL C,63H;
ORL C,54H;
ORL C,23H;
ORL C,/23H;
MOV C,63H;
MOV C,54H;
MOV C,23H;
MOV 63H,C;
MOV 54H,C;
MOV 23H,C;
MOV A,R0;
MOV A,R7;
MOV A,R3;
MOV A,63H;
MOV A,54H;
MOV A,23H;
MOV A,@R0;
MOV A,@R1;
MOV A,#1234H;
MOV A,#12H;
MOV A,#78H;
MOV R0,A;
MOV R7,A;
MOV R3,A;
MOV R0,63H;
MOV R0,54H;
MOV R0,23H;
MOV R7,63H;
MOV R7,54H;
MOV R7,23H;
MOV R3,63H;
MOV R3,54H;
MOV R3,23H;
MOV R0,#1234H;
MOV R0,#12H;
MOV R0,#78H;
MOV R7,#1234H;
MOV R7,#12H;
MOV R7,#78H;
MOV R3,#1234H;
MOV R3,#12H;
MOV R3,#78H;
MOV 63H,A;
MOV 54H,A;
MOV 23H,A;
MOV 63H,R0;
MOV 63H,R7;
MOV 63H,R3;
MOV 54H,R0;
MOV 54H,R7;
MOV 54H,R3;
MOV 23H,R0;
MOV 23H,R7;
MOV 23H,R3;
MOV 63H,63H;
MOV 63H,54H;
MOV 63H,23H;
MOV 54H,63H;
MOV 54H,54H;
MOV 54H,23H;
MOV 23H,63H;
MOV 23H,54H;
MOV 23H,23H;
MOV 63H,@R0;
MOV 63H,@R1;
MOV 54H,@R0;
MOV 54H,@R1;
MOV 23H,@R0;
MOV 23H,@R1;
MOV 63H,#1234H;
MOV 63H,#12H;
MOV 63H,#78H;
MOV 54H,#1234H;
MOV 54H,#12H;
MOV 54H,#78H;
MOV 23H,#1234H;
MOV 23H,#12H;
MOV 23H,#78H;
MOV @R0,A;
MOV @R1,A;
MOV @R0,63H;
MOV @R0,54H;
MOV @R0,23H;
MOV @R1,63H;
MOV @R1,54H;
MOV @R1,23H;
MOV @R0,#1234H;
MOV @R0,#12H;
MOV @R0,#78H;
MOV @R1,#1234H;
MOV @R1,#12H;
MOV @R1,#78H;
MOV DPTR,#1234H;
MOV DPTR,#12H;
MOV DPTR,#78H;
MOVC A,@A+DPTR;
MOVC A,@A+PC;
MOVX A,@R0;
MOVX A,@R1;
MOVX A,@DPTR;
MOVX @R0,A;
MOVX @R1,A;
MOVX @DPTR,A;
PUSH 63H;
PUSH 54H;
PUSH 23H;
POP 63H;
POP 54H;
POP 23H;
XCH A,R0;
XCH A,R7;
XCH A,R3;
XCH A,63H;
XCH A,54H;
XCH A,23H;
XCH A,@R0;
XCH A,@R1;
XCHD A,@R0;
XCHD A,@R1;
ANL A,R0;
ANL A,R7;
ANL A,R3;
ANL A,63H;
ANL A,54H;
ANL A,23H;
ANL A,@R0;
ANL A,@R1;
ANL A,#1234H;
ANL A,#12H;
ANL A,#78H;
ANL 63H,A;
ANL 54H,A;
ANL 23H,A;
ANL 63H,#1234H;
ANL 63H,#12H;
ANL 63H,#78H;
ANL 54H,#1234H;
ANL 54H,#12H;
ANL 54H,#78H;
ANL 23H,#1234H;
ANL 23H,#12H;
ANL 23H,#78H;
ORL A,R0;
ORL A,R7;
ORL A,R3;
ORL A,63H;
ORL A,54H;
ORL A,23H;
ORL A,@R0;
ORL A,@R1;
ORL A,#1234H;
ORL A,#12H;
ORL A,#78H;
ORL 63H,A;
ORL 54H,A;
ORL 23H,A;
ORL 63H,#1234H;
ORL 63H,#12H;
ORL 63H,#78H;
ORL 54H,#1234H;
ORL 54H,#12H;
ORL 54H,#78H;
ORL 23H,#1234H;
ORL 23H,#12H;
ORL 23H,#78H;
XRL A,R0;
XRL A,R7;
XRL A,R3;
XRL A,63H;
XRL A,54H;
XRL A,23H;
XRL A,@R0;
XRL A,@R1;
XRL A,#1234H;
XRL A,#12H;
XRL A,#78H;
XRL 63H,A;
XRL 54H,A;
XRL 23H,A;
XRL 63H,#1234H;
XRL 63H,#12H;
XRL 63H,#78H;
XRL 54H,#1234H;
XRL 54H,#12H;
XRL 54H,#78H;
XRL 23H,#1234H;
XRL 23H,#12H;
XRL 23H,#78H;
CLR A;
CPL A;
RL A;
RLC A;
RR A;
RRC A;
SWAP A;

NOP;

END
	